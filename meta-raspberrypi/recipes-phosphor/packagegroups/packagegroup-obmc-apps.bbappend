RDEPENDS:${PN}-extras:append:raspberrypi2 = " \
                                          phosphor-led-manager \
                                          phosphor-hwmon \
                                          phosphor-webui \
                                         "

