OBMC_IMAGE_EXTRA_INSTALL += " bc htop fru-macaddr ipmitool"
