EXTRA_OEMESON:append = " -Drest=enabled"
