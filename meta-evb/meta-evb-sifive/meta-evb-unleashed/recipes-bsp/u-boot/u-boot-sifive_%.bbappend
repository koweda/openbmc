COMPATIBLE_MACHINE = "(freedom-u540|qemuriscv64|unmatched|evb-unleashed)"
