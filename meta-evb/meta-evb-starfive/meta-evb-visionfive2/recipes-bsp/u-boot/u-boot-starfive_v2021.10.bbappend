FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
PROVIDES += "u-boot"
